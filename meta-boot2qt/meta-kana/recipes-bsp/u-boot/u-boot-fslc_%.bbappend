COMPATIBLE_MACHINE = "(mxs|mx3|mx5|mx6|mx7|vf|use-mainline-bsp)"
